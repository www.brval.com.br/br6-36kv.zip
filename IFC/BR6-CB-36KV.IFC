Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: BR6-CB-36KV.IFC
Time: 2020-07-30T14:36:25
Author: PROJETOS_1
Organization: Microsoft
Written by: SwIFC
Made in: SolidWorks 2014

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
